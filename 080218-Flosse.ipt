# Autodesk Inventor part: 080218-Flosse
## iProperties
Created: 2008-02
Part Number: 080218-Flosse
Document SubType Name: Modeling
Designer: mp
## Feature names
1. Extrusion1
